Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-05-03T18:51:45
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180216_1515(x64) - Exporter 19.0.0.405 - Alternate UI 19.0.0.405
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed May 03 18:51:45 2023 * Host: DESKTOP-6FF1F60 * Database: C:\Users\Artec89\AppData\Local\Temp\{2FAF4524-A205-402E-93B6-4BAF66BBCDD1}\ifc * Database version: 5507 * Database creation date: Wed May 03 18:51:42 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed May 03 18:51:44 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed May 03 18:51:44 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcFlowTerminal: Codie Basin Mixer W/ Pop-up, FFASB201-101500BF0_REVIT:Codie Basin Mixer W/ Pop-up:344807
In: Level 1
Material: Chrome
Pset_DistributionFlowElementCommon - Reference: Codie Basin Mixer W/ Pop-up
